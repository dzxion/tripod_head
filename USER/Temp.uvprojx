# Keil uVision project Temp.uvprojx, settings and files
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303CB STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.1
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x0000A000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,__CC_ARM,__FPU_PRESENT=1,__FPU_USED=1 ,ARM_MATH_CM4,VECT_TAB_OFFSET=0x0
  c include: ..\CORE\Include;..\USER;..\STM32F30x_StdPeriph_Driver\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE;..\SYSTEM\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: ..\HARDWARE\Gimbal3Axis_Debug.sct
  group USER
    ./: main.c stm32f30x_it.c system_stm32f30x.c
    ../HARDWARE/: app.h app.c
  group CORE
    ../CORE/Source/: startup_stm32f30x.s
  group STM32F30x_StdPeriph_Driver
    ../STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_misc.c stm32f30x_spi.c stm32f30x_exti.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_flash.c stm32f30x_dma.c stm32f30x_can.c stm32f30x_pwr.c stm32f30x_rtc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/: led.c MPU6500.c timer.c Gpio_Config.c Debug.c AHRS.c Calibration.c FOC_LIB.lib Motor_Tim.c Motor_Control.c can.c superx_ii_api.c cpu.c math_common.c ESKF.c
  group CMSIS
    ./: arm_cortexM4lf_math.lib
